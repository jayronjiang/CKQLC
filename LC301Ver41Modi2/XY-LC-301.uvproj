# Keil uVision project XY-LC-301.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: XY-LC-301 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: XY-LC301.C Test.c STARTUP.A51
  group Documents
    ./: Readme.txt
